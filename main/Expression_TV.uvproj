# Keil uVision project Expression_TV.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Expression_TV +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./: Expression_TV.c config.h
  group MPU6050
    ./: mpu6050.h mpu6050.c
  group UART
    ./: uart.h uart.c
  group OLED
    ./: bmp.h oled.h oledfont.h oled.c
